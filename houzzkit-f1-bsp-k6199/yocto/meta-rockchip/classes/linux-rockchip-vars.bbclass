LINUX_BUILD_DIR := "${TMPDIR}/work/${MACHINE_ARCH}-poky-linux/linux-rockchip/${LINUX_VERSION}-${PR}/linux-${MACHINE_ARCH}-standard-build"
